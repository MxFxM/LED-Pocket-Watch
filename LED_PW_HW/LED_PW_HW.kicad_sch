File: LED_PW_HW/LED_PW_HW.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: schematic of led driver part done
